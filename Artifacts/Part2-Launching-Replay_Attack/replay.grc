options:
  parameters:
    author: pragya
    generate_options: qt_gui
    id: replay
    output_language: python
    title: Not titled yet
  states: {state: disabled}

blocks:
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pragya/Downloads/record29.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '80000000'
    fc: '902000000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '80000000'
    center_freq0: '902000000'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: '10000000'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
